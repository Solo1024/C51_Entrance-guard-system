# Keil uVision project 门禁.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 门禁 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\arc
  group Source Group 1
    ./: STARTUP.A51
  group scr
    ./arc/: main.c rc522.c
